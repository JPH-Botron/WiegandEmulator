// pico_wiegand_dispatcher.c — K&R style
// -----------------------------------------------------------------------------
// Readable JSON (NDJSON) command dispatcher for Raspberry Pi Pico USB CDC.
// Wiegand bridge control plane with clean K&R brace style and 4-space indents.
// -----------------------------------------------------------------------------

#include <stdio.h>
#include <string.h>
#include <stdlib.h>
#include <stdbool.h>
#include <stdint.h>

#include "pico/stdlib.h"

/* --------------------------- Configuration & Limits ------------------------ */
#define MAX_LINE_BYTES   768
#define MAX_JSON_TOKENS  128
#define MAX_HEX_LEN      128

#define BIT_MIN_US       20
#define BIT_MAX_US       20000
#define IBIT_MIN_US      20
#define IBIT_MAX_US      20000
#define PWIDTH_MIN_US    10
#define PWIDTH_MAX_US    10000

#define MAX_BITS         512

/* ------------------------------- JSMN (MIT) ------------------------------- */
#ifndef JSMN_HEADER
#define JSMN_HEADER

typedef enum {
    JSMN_ERROR_NOMEM = -1,
    JSMN_ERROR_INVAL = -2,
    JSMN_ERROR_PART  = -3,
    JSMN_SUCCESS     = 0
} jsmnerr_t;

typedef enum {
    JSMN_UNDEFINED = 0,
    JSMN_OBJECT    = 1,
    JSMN_ARRAY     = 2,
    JSMN_STRING    = 3,
    JSMN_PRIMITIVE = 4
} jsmntype_t;

typedef struct {
    jsmntype_t type;
    int start, end, size, parent;
} jsmntok_t;

typedef struct {
    unsigned int pos;
    unsigned int toknext;
    int toksuper;
} jsmn_parser;

static void jsmn_init(jsmn_parser *p)
{
    p->pos = 0; p->toknext = 0; p->toksuper = -1;
}

static jsmnerr_t jsmn_parse(jsmn_parser *p, const char *js, unsigned int len,
                            jsmntok_t *t, unsigned int nt)
{
    #define JSMN_ALLOC_TOKEN() ( (p->toknext>=nt) ? NULL : (t[p->toknext].start = t[p->toknext].end = -1, \
                                     t[p->toknext].size = 0, t[p->toknext].parent = -1, &t[p->toknext++]) )
    unsigned int i; jsmntok_t *tok;

    for (; p->pos < len && js[p->pos]; p->pos++) {
        switch (js[p->pos]) {
        case '{': case '[':
            tok = JSMN_ALLOC_TOKEN(); if (!tok) return JSMN_ERROR_NOMEM;
            tok->type = (js[p->pos] == '{' ? JSMN_OBJECT : JSMN_ARRAY);
            tok->start = p->pos; tok->parent = p->toksuper; p->toksuper = (int)(p->toknext - 1);
            break;
        case '}': case ']':
            for (i = p->toknext; i > 0; i--) {
                tok = &t[i - 1];
                if (tok->start != -1 && tok->end == -1) { tok->end = p->pos + 1; p->toksuper = tok->parent; break; }
            }
            break;
        case '"': {
            tok = JSMN_ALLOC_TOKEN(); if (!tok) return JSMN_ERROR_NOMEM; tok->type = JSMN_STRING; tok->start = ++p->pos;
            for (; p->pos < len && js[p->pos]; p->pos++) {
                char c = js[p->pos];
                if (c == '"') { tok->end = p->pos; tok->parent = p->toksuper; if (p->toksuper != -1) t[p->toksuper].size++; break; }
                if (c == '\') p->pos++;
            }
            if (tok->end == -1) return JSMN_ERROR_PART;
        } break;
        default:
            if (js[p->pos] <= ' ') break; if (js[p->pos] == ':' || js[p->pos] == ',') break;
            tok = JSMN_ALLOC_TOKEN(); if (!tok) return JSMN_ERROR_NOMEM; tok->type = JSMN_PRIMITIVE; tok->start = p->pos;
            for (; p->pos < len && js[p->pos]; p->pos++) {
                char c = js[p->pos];
                if (c == ',' || c == ']' || c == '}' || c <= ' ') { tok->end = p->pos; break; }
            }
            if (tok->end == -1) tok->end = p->pos; tok->parent = p->toksuper; if (p->toksuper != -1) t[p->toksuper].size++; p->pos--;
            break;
        }
    }
    return JSMN_SUCCESS;
}
#endif /* JSMN_HEADER */

/* --------------------------------- Types ---------------------------------- */
typedef enum { ROLE_DISABLED = 0, ROLE_TX = 1, ROLE_RX = 2 } port_role_t;

typedef struct {
    uint32_t bit_us;         /* time between bit starts */
    uint32_t interbit_us;    /* idle gap inside a frame */
    uint32_t pulse_width_us; /* active-low pulse width */
} tx_timing_t;

typedef struct {
    uint32_t end_of_frame_us; /* silence that ends a frame */
    uint32_t debounce_us;     /* ignore pulses shorter than this */
} rx_params_t;

typedef struct {
    port_role_t role;
    const char *state;        /* "idle" | "tx_busy" | "rx_armed" */

    tx_timing_t tx;
    rx_params_t rx;

    uint32_t tx_frames, tx_errors;
    uint32_t rx_frames, rx_errors, rx_overruns;

    bool     last_present;
    uint32_t last_bits;
    char     last_hex[MAX_HEX_LEN];
    uint32_t bit_avg, interbit_avg, pulse_width_avg;
    uint64_t last_ts_ms;

    bool rx_listening;
} port_t;

static port_t g_ports[2];

/* ------------------------------ Declarations ------------------------------ */
static void dispatch_line(char *line);
static bool hal_tx_start(int port, uint32_t bits, const char *hex, int repeat, uint32_t interframe_us);
static void hal_tx_abort(int port);
static void hal_rx_arm(int port, bool enable);

/* -------------------------------- Utilities -------------------------------- */
static int tok_len(const jsmntok_t *t)
{
    return t->end - t->start;
}

static char *tok_strdup(const char *js, const jsmntok_t *t)
{
    int n = tok_len(t);
    char *s = (char *)malloc((size_t)n + 1);
    if (!s) return NULL;
    memcpy(s, js + t->start, (size_t)n);
    s[n] = '';
    return s;
}

static bool tok_eq(const char *js, const jsmntok_t *t, const char *lit)
{
    int n = tok_len(t);
    return (int)strlen(lit) == n && strncmp(js + t->start, lit, (size_t)n) == 0;
}

static bool tok_to_long(const char *js, const jsmntok_t *t, long *out)
{
    char *s = tok_strdup(js, t); if (!s) return false;
    char *end = NULL; long v = strtol(s, &end, 10);
    bool ok = (end && *end == '');
    free(s); if (ok && out) *out = v; return ok;
}

static const jsmntok_t *obj_get(const char *js, const jsmntok_t *toks, int root_idx, int tokc, const char *key)
{
    const jsmntok_t *root = &toks[root_idx];
    int children, i;

    if (root->type != JSMN_OBJECT) return NULL;
    children = root->size; i = root_idx + 1;

    while (children-- > 0 && i < tokc) {
        const jsmntok_t *k = &toks[i++];
        const jsmntok_t *v;
        if (i >= tokc) break;
        v = &toks[i++];
        if (k->type == JSMN_STRING && tok_eq(js, k, key)) return v;
        if (v->type == JSMN_OBJECT || v->type == JSMN_ARRAY) {
            int open = 1, j = (int)(v - toks) + 1;
            while (open > 0 && j < tokc) {
                if (toks[j].end == -1) { j++; continue; }
                if (toks[j].type == JSMN_OBJECT || toks[j].type == JSMN_ARRAY) open++;
                if (toks[j].parent < (int)(v - toks)) open--;
                j++;
            }
            i = j;
        }
    }
    return NULL;
}

static void reply_ok_id(const char *id_json)
{
    printf("{\"id\":%s,\"ok\":true}
", id_json ? id_json : "null");
}

static void reply_ok_data(const char *id_json, const char *data_obj_json)
{
    printf("{\"id\":%s,\"ok\":true,\"data\":%s}
", id_json ? id_json : "null", data_obj_json ? data_obj_json : "null");
}

static void reply_err(const char *id_json, const char *code, const char *msg)
{
    if (!code) code = "ERR"; if (!msg) msg = "";
    printf("{\"id\":%s,\"ok\":false,\"err\":{\"code\":\"%s\",\"msg\":\"%s\"}}
",
           id_json ? id_json : "null", code, msg);
}

/* ----------------------------------- HAL ----------------------------------- */
static bool hal_tx_start(int port, uint32_t bits, const char *hex, int repeat, uint32_t interframe_us)
{
    (void)port; (void)bits; (void)hex; (void)repeat; (void)interframe_us; /* TODO */
    return true;
}

static void hal_tx_abort(int port)
{
    (void)port; /* TODO */
}

static void hal_rx_arm(int port, bool enable)
{
    (void)port; (void)enable; /* TODO */
}

/* ------------------------------- Handlers ---------------------------------- */
static bool valid_port(long p)
{
    return p == 0 || p == 1;
}

static void handle_ping(const char *id_json, const char *js, jsmntok_t *toks, int tokc, int args_idx)
{
    const jsmntok_t *nonce = NULL;
    char *nonce_str = NULL;
    uint64_t ms;
    char buf[160];

    if (args_idx >= 0) nonce = obj_get(js, toks, args_idx, tokc, "nonce");
    if (nonce) nonce_str = tok_strdup(js, nonce);

    ms = to_ms_since_boot(get_absolute_time());
    if (nonce_str) {
        char esc[120]; size_t i = 0, o = 0;
        for (; nonce_str[i] && o < sizeof(esc) - 2; i++) {
            char c = nonce_str[i];
            if (c == '\' || c == '"') { esc[o++] = '\'; esc[o++] = c; }
            else if (c == '
') { esc[o++] = '\'; esc[o++] = 'n'; }
            else esc[o++] = c;
        }
        esc[o] = '';
        snprintf(buf, sizeof(buf), "{\"nonce\":\"%s\",\"uptime_ms\":%llu}", esc, (unsigned long long)ms);
    } else {
        snprintf(buf, sizeof(buf), "{\"nonce\":null,\"uptime_ms\":%llu}", (unsigned long long)ms);
    }
    reply_ok_data(id_json, buf);
    free(nonce_str);
}

static void handle_get_info(const char *id_json)
{
    reply_ok_data(id_json,
        "{\"fw\":\"wiegand-bridge 0.1.0\",\"build\":\"local\",\"device\":\"Raspberry Pi Pico\",\"ports\":[0,1],\"rx_max_bits\":512,\"tx_max_bits\":512,\"timing_limits_us\":{\"bit\":[20,20000],\"interbit\":[20,20000],\"pulse_width\":[10,10000]}}"
    );
}

static void handle_set_port_role(const char *id_json, const char *js, jsmntok_t *toks, int tokc, int args_idx)
{
    const jsmntok_t *pt, *rt;
    long p;

    if (args_idx < 0) { reply_err(id_json, "BAD_ARG", "args required"); return; }
    pt = obj_get(js, toks, args_idx, tokc, "port");
    rt = obj_get(js, toks, args_idx, tokc, "role");
    if (!pt || !tok_to_long(js, pt, &p) || !valid_port(p)) { reply_err(id_json, "BAD_PORT", "port must be 0 or 1"); return; }
    if (!rt || rt->type != JSMN_STRING) { reply_err(id_json, "BAD_ARG", "role required"); return; }

    if (tok_eq(js, rt, "tx")) g_ports[p].role = ROLE_TX;
    else if (tok_eq(js, rt, "rx")) g_ports[p].role = ROLE_RX;
    else if (tok_eq(js, rt, "disabled")) g_ports[p].role = ROLE_DISABLED;
    else { reply_err(id_json, "BAD_ARG", "invalid role"); return; }

    hal_tx_abort((int)p);
    g_ports[p].state = "idle";
    g_ports[p].rx_listening = false;
    g_ports[p].last_present = false;

    reply_ok_id(id_json);
}

static void handle_get_port_status(const char *id_json, long p)
{
    char out[400];

    if (!valid_port(p)) { reply_err(id_json, "BAD_PORT", "port must be 0 or 1"); return; }
    snprintf(out, sizeof(out),
        "{\"port\":%ld,\"role\":\"%s\",\"tx_timing_us\":{\"bit\":%u,\"interbit\":%u,\"pulse_width\":%u},\"rx_params_us\":{\"end_of_frame\":%u,\"debounce\":%u},\"state\":\"%s\"}",
        p,
        g_ports[p].role == ROLE_TX ? "tx" : (g_ports[p].role == ROLE_RX ? "rx" : "disabled"),
        g_ports[p].tx.bit_us, g_ports[p].tx.interbit_us, g_ports[p].tx.pulse_width_us,
        g_ports[p].rx.end_of_frame_us, g_ports[p].rx.debounce_us,
        g_ports[p].state ? g_ports[p].state : "idle");
    reply_ok_data(id_json, out);
}

static void handle_set_tx_timing(const char *id_json, const char *js, jsmntok_t *toks, int tokc, int args_idx)
{
    long p, bit, ibit, pw = 100;
    const jsmntok_t *pt, *tb, *ti, *tp;

    if (args_idx < 0) { reply_err(id_json, "BAD_ARG", "args required"); return; }
    pt = obj_get(js, toks, args_idx, tokc, "port");
    if (!pt || !tok_to_long(js, pt, &p) || !valid_port(p)) { reply_err(id_json, "BAD_PORT", "port"); return; }
    if (g_ports[p].role != ROLE_TX) { reply_err(id_json, "BAD_ROLE", "port not TX"); return; }

    tb = obj_get(js, toks, args_idx, tokc, "bit_us");
    ti = obj_get(js, toks, args_idx, tokc, "interbit_us");
    tp = obj_get(js, toks, args_idx, tokc, "pulse_width_us");
    if (!tb || !ti || !tok_to_long(js, tb, &bit) || !tok_to_long(js, ti, &ibit)) { reply_err(id_json, "BAD_ARG", "bit_us and interbit_us required"); return; }
    if (tp && !tok_to_long(js, tp, &pw)) { reply_err(id_json, "BAD_ARG", "pulse_width_us bad"); return; }

    if (bit < BIT_MIN_US || bit > BIT_MAX_US || ibit < IBIT_MIN_US || ibit > IBIT_MAX_US || pw < PWIDTH_MIN_US || pw > PWIDTH_MAX_US) {
        reply_err(id_json, "BAD_ARG", "timing out of range"); return;
    }

    g_ports[p].tx.bit_us = (uint32_t)bit;
    g_ports[p].tx.interbit_us = (uint32_t)ibit;
    g_ports[p].tx.pulse_width_us = (uint32_t)pw;
    reply_ok_id(id_json);
}

static void handle_get_tx_timing(const char *id_json, long p)
{
    char out[160];

    if (!valid_port(p)) { reply_err(id_json, "BAD_PORT", "port"); return; }
    snprintf(out, sizeof(out), "{\"bit_us\":%u,\"interbit_us\":%u,\"pulse_width_us\":%u}",
             g_ports[p].tx.bit_us, g_ports[p].tx.interbit_us, g_ports[p].tx.pulse_width_us);
    reply_ok_data(id_json, out);
}

static void handle_tx_frame(const char *id_json, const char *js, jsmntok_t *toks, int tokc, int args_idx)
{
    long p, bits, repeat = 1, interframe = 10000;
    const jsmntok_t *pt, *bt, *hx, *rp, *ifg;
    char *hex;
    bool started;

    if (args_idx < 0) { reply_err(id_json, "BAD_ARG", "args required"); return; }
    pt = obj_get(js, toks, args_idx, tokc, "port");
    bt = obj_get(js, toks, args_idx, tokc, "bits");
    hx = obj_get(js, toks, args_idx, tokc, "data_hex");
    rp = obj_get(js, toks, args_idx, tokc, "repeat");
    ifg = obj_get(js, toks, args_idx, tokc, "interframe_us");

    if (!pt || !tok_to_long(js, pt, &p) || !valid_port(p)) { reply_err(id_json, "BAD_PORT", "port"); return; }
    if (g_ports[p].role != ROLE_TX) { reply_err(id_json, "BAD_ROLE", "port not TX"); return; }
    if (!bt || !tok_to_long(js, bt, &bits) || bits <= 0 || bits > MAX_BITS) { reply_err(id_json, "BAD_ARG", "bits out of range"); return; }
    if (!hx || hx->type != JSMN_STRING) { reply_err(id_json, "BAD_ARG", "data_hex required"); return; }
    if (rp && !tok_to_long(js, rp, &repeat)) { reply_err(id_json, "BAD_ARG", "repeat"); return; }
    if (ifg && !tok_to_long(js, ifg, &interframe)) { reply_err(id_json, "BAD_ARG", "interframe_us"); return; }

    hex = tok_strdup(js, hx);
    /* TODO: validate hex length vs bits (MSB-first truncation rule) */

    started = hal_tx_start((int)p, (uint32_t)bits, hex, (int)repeat, (uint32_t)interframe);
    if (started) { g_ports[p].state = "tx_busy"; reply_ok_id(id_json); }
    else { reply_err(id_json, "BUSY", "tx already in progress"); }
    free(hex);
}

static void handle_rx_listen(const char *id_json, const char *js, jsmntok_t *toks, int tokc, int args_idx)
{
    long p; const jsmntok_t *pt, *en; char *s; bool enable = false;

    if (args_idx < 0) { reply_err(id_json, "BAD_ARG", "args required"); return; }
    pt = obj_get(js, toks, args_idx, tokc, "port");
    if (!pt || !tok_to_long(js, pt, &p) || !valid_port(p)) { reply_err(id_json, "BAD_PORT", "port"); return; }
    en = obj_get(js, toks, args_idx, tokc, "enable"); if (!en) { reply_err(id_json, "BAD_ARG", "enable required"); return; }

    if (en->type == JSMN_PRIMITIVE) {
        s = tok_strdup(js, en); if (!s) { reply_err(id_json, "ERR", "oom"); return; }
        enable = (strcmp(s, "true") == 0 || strcmp(s, "1") == 0);
        free(s);
    } else {
        reply_err(id_json, "BAD_ARG", "enable must be bool"); return;
    }

    g_ports[p].rx_listening = enable;
    g_ports[p].state = enable ? "rx_armed" : "idle";
    hal_rx_arm((int)p, enable);
    reply_ok_id(id_json);
}

static void handle_set_rx_params(const char *id_json, const char *js, jsmntok_t *toks, int tokc, int args_idx)
{
    long p, eof, db; const jsmntok_t *pt, *te, *td;

    if (args_idx < 0) { reply_err(id_json, "BAD_ARG", "args required"); return; }
    pt = obj_get(js, toks, args_idx, tokc, "port"); if (!pt || !tok_to_long(js, pt, &p) || !valid_port(p)) { reply_err(id_json, "BAD_PORT", "port"); return; }
    te = obj_get(js, toks, args_idx, tokc, "end_of_frame_us");
    td = obj_get(js, toks, args_idx, tokc, "debounce_us");
    if (!te || !td || !tok_to_long(js, te, &eof) || !tok_to_long(js, td, &db)) { reply_err(id_json, "BAD_ARG", "end_of_frame_us and debounce_us required"); return; }

    g_ports[p].rx.end_of_frame_us = (uint32_t)eof;
    g_ports[p].rx.debounce_us = (uint32_t)db;
    reply_ok_id(id_json);
}

static void handle_get_rx_params(const char *id_json, long p)
{
    char out[160];

    if (!valid_port(p)) { reply_err(id_json, "BAD_PORT", "port"); return; }
    snprintf(out, sizeof(out), "{\"end_of_frame_us\":%u,\"debounce_us\":%u}", g_ports[p].rx.end_of_frame_us, g_ports[p].rx.debounce_us);
    reply_ok_data(id_json, out);
}

static void handle_get_rx_last(const char *id_json, long p)
{
    char out[360];

    if (!valid_port(p)) { reply_err(id_json, "BAD_PORT", "port"); return; }
    if (!g_ports[p].last_present) { reply_ok_data(id_json, "{\"present\":false}"); return; }

    snprintf(out, sizeof(out),
        "{\"present\":true,\"bits\":%u,\"data_hex\":\"%s\",\"measured_us\":{\"bit_avg\":%u,\"interbit_avg\":%u,\"pulse_width_avg\":%u},\"pulses\":%u,\"ts_ms\":%llu}",
        g_ports[p].last_bits, g_ports[p].last_hex, g_ports[p].bit_avg, g_ports[p].interbit_avg, g_ports[p].pulse_width_avg, g_ports[p].last_bits, (unsigned long long)g_ports[p].last_ts_ms);
    reply_ok_data(id_json, out);
}

static void handle_clear_rx_last(const char *id_json, long p)
{
    if (!valid_port(p)) { reply_err(id_json, "BAD_PORT", "port"); return; }
    g_ports[p].last_present = false;
    reply_ok_id(id_json);
}

static void handle_get_stats(const char *id_json, long p)
{
    char out[200];

    if (!valid_port(p)) { reply_err(id_json, "BAD_PORT", "port"); return; }
    snprintf(out, sizeof(out), "{\"tx_frames\":%u,\"tx_errors\":%u,\"rx_frames\":%u,\"rx_errors\":%u,\"rx_overruns\":%u}",
             g_ports[p].tx_frames, g_ports[p].tx_errors, g_ports[p].rx_frames, g_ports[p].rx_errors, g_ports[p].rx_overruns);
    reply_ok_data(id_json, out);
}

static void handle_reset_port(const char *id_json, long p)
{
    if (!valid_port(p)) { reply_err(id_json, "BAD_PORT", "port"); return; }
    hal_tx_abort((int)p);
    g_ports[p].state = "idle";
    g_ports[p].rx_listening = false;
    reply_ok_id(id_json);
}

static void handle_save_config(const char *id_json)
{
    /* TODO: persist to flash */
    reply_ok_id(id_json);
}

static void handle_load_defaults(const char *id_json)
{
    int p;
    for (p = 0; p < 2; p++) {
        g_ports[p].tx.bit_us          = 2000;
        g_ports[p].tx.interbit_us     = 2000;
        g_ports[p].tx.pulse_width_us  = 100;
        g_ports[p].rx.end_of_frame_us = 5000;
        g_ports[p].rx.debounce_us     = 5;
        g_ports[p].role = ROLE_DISABLED;
        g_ports[p].state = "idle";
        g_ports[p].rx_listening = false;
        g_ports[p].last_present = false;
    }
    reply_ok_id(id_json);
}

/* ------------------------------- Dispatcher -------------------------------- */
static void dispatch_line(char *line)
{
    jsmn_parser p; jsmntok_t tok[MAX_JSON_TOKENS];
    const jsmntok_t *id_tok, *cmd_tok, *args_tok;
    char *id_json = NULL, *cmd = NULL;
    int args_idx, root = 0;

    jsmn_init(&p);
    if (jsmn_parse(&p, line, (unsigned)strlen(line), tok, MAX_JSON_TOKENS) < 0 || tok[0].type != JSMN_OBJECT) {
        reply_err(NULL, "BAD_CMD", "invalid json");
        return;
    }

    id_tok   = obj_get(line, tok, root, MAX_JSON_TOKENS, "id");
    cmd_tok  = obj_get(line, tok, root, MAX_JSON_TOKENS, "cmd");
    args_tok = obj_get(line, tok, root, MAX_JSON_TOKENS, "args");
    if (id_tok) id_json = tok_strdup(line, id_tok);
    if (!cmd_tok || cmd_tok->type != JSMN_STRING) { reply_err(id_json, "BAD_CMD", "cmd missing or not string"); free(id_json); return; }

    cmd = tok_strdup(line, cmd_tok);
    args_idx = args_tok ? (int)(args_tok - tok) : -1;

    if (strcmp(cmd, "ping") == 0) {
        handle_ping(id_json, line, tok, MAX_JSON_TOKENS, args_idx);
    } else if (strcmp(cmd, "get_info") == 0) {
        handle_get_info(id_json);
    } else if (strcmp(cmd, "set_port_role") == 0) {
        handle_set_port_role(id_json, line, tok, MAX_JSON_TOKENS, args_idx);
    } else if (strcmp(cmd, "get_port_status") == 0) {
        long p; const jsmntok_t *pt;
        if (args_idx < 0) { reply_err(id_json, "BAD_ARG", "port required"); }
        else { pt = obj_get(line, tok, args_idx, MAX_JSON_TOKENS, "port"); if (!pt || !tok_to_long(line, pt, &p)) reply_err(id_json, "BAD_ARG", "port required"); else handle_get_port_status(id_json, p); }
    } else if (strcmp(cmd, "set_tx_timing") == 0) {
        handle_set_tx_timing(id_json, line, tok, MAX_JSON_TOKENS, args_idx);
    } else if (strcmp(cmd, "get_tx_timing") == 0) {
        long p; const jsmntok_t *pt;
        if (args_idx < 0) { reply_err(id_json, "BAD_ARG", "port required"); }
        else { pt = obj_get(line, tok, args_idx, MAX_JSON_TOKENS, "port"); if (!pt || !tok_to_long(line, pt, &p)) reply_err(id_json, "BAD_ARG", "port required"); else handle_get_tx_timing(id_json, p); }
    } else if (strcmp(cmd, "tx_frame") == 0) {
        handle_tx_frame(id_json, line, tok, MAX_JSON_TOKENS, args_idx);
    } else if (strcmp(cmd, "rx_listen") == 0) {
        handle_rx_listen(id_json, line, tok, MAX_JSON_TOKENS, args_idx);
    } else if (strcmp(cmd, "set_rx_params") == 0) {
        handle_set_rx_params(id_json, line, tok, MAX_JSON_TOKENS, args_idx);
    } else if (strcmp(cmd, "get_rx_params") == 0) {
        long p; const jsmntok_t *pt;
        if (args_idx < 0) { reply_err(id_json, "BAD_ARG", "port required"); }
        else { pt = obj_get(line, tok, args_idx, MAX_JSON_TOKENS, "port"); if (!pt || !tok_to_long(line, pt, &p)) reply_err(id_json, "BAD_ARG", "port required"); else handle_get_rx_params(id_json, p); }
    } else if (strcmp(cmd, "get_rx_last") == 0) {
        long p; const jsmntok_t *pt;
        if (args_idx < 0) { reply_err(id_json, "BAD_ARG", "port required"); }
        else { pt = obj_get(line, tok, args_idx, MAX_JSON_TOKENS, "port"); if (!pt || !tok_to_long(line, pt, &p)) reply_err(id_json, "BAD_ARG", "port required"); else handle_get_rx_last(id_json, p); }
    } else if (strcmp(cmd, "clear_rx_last") == 0) {
        long p; const jsmntok_t *pt;
        if (args_idx < 0) { reply_err(id_json, "BAD_ARG", "port required"); }
        else { pt = obj_get(line, tok, args_idx, MAX_JSON_TOKENS, "port"); if (!pt || !tok_to_long(line, pt, &p)) reply_err(id_json, "BAD_ARG", "port required"); else handle_clear_rx_last(id_json, p); }
    } else if (strcmp(cmd, "get_stats") == 0) {
        long p; const jsmntok_t *pt;
        if (args_idx < 0) { reply_err(id_json, "BAD_ARG", "port required"); }
        else { pt = obj_get(line, tok, args_idx, MAX_JSON_TOKENS, "port"); if (!pt || !tok_to_long(line, pt, &p)) reply_err(id_json, "BAD_ARG", "port required"); else handle_get_stats(id_json, p); }
    } else if (strcmp(cmd, "reset_port") == 0) {
        long p; const jsmntok_t *pt;
        if (args_idx < 0) { reply_err(id_json, "BAD_ARG", "port required"); }
        else { pt = obj_get(line, tok, args_idx, MAX_JSON_TOKENS, "port"); if (!pt || !tok_to_long(line, pt, &p)) reply_err(id_json, "BAD_ARG", "port required"); else handle_reset_port(id_json, p); }
    } else if (strcmp(cmd, "save_config") == 0) {
        handle_save_config(id_json);
    } else if (strcmp(cmd, "load_defaults") == 0) {
        handle_load_defaults(id_json);
    } else {
        reply_err(id_json, "BAD_CMD", "unknown command");
    }

    free(cmd);
    free(id_json);
}

/* ----------------------------------- Main ---------------------------------- */
int main(void)
{
    int i;

    stdio_init_all();

    for (i = 0; i < 2; i++) {
        g_ports[i].role = ROLE_DISABLED;
        g_ports[i].state = "idle";
        g_ports[i].rx_listening = false;
        g_ports[i].last_present = false;

        g_ports[i].tx.bit_us         = 2000;
        g_ports[i].tx.interbit_us    = 2000;
        g_ports[i].tx.pulse_width_us = 100;

        g_ports[i].rx.end_of_frame_us = 5000;
        g_ports[i].rx.debounce_us     = 5;

        g_ports[i].tx_frames = g_ports[i].tx_errors = 0;
        g_ports[i].rx_frames = g_ports[i].rx_errors = g_ports[i].rx_overruns = 0;
    }

    sleep_ms(1200); /* let USB enumerate */

    {
        static char line[MAX_LINE_BYTES];
        size_t n = 0;
        for (;;) {
            int c = getchar_timeout_us(20000);
            if (c == PICO_ERROR_TIMEOUT) continue;
            if (c == '
') continue;
            if (c == '
') {
                line[n] = '';
                if (n > 0) dispatch_line(line);
                n = 0;
                continue;
            }
            if (c >= 0) {
                if (n < sizeof(line) - 1) line[n++] = (char)c;
                else { n = 0; reply_err(NULL, "BAD_CMD", "line too long"); }
            }
        }
    }
}
